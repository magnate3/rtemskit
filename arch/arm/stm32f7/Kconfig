## arch/arm/stm32f7/Kconfig
```kconfig
# Board configuration options

if BOARD_STM32F7

config SOC_SERIES_STM32F7X
  bool
  
  
endif
```
